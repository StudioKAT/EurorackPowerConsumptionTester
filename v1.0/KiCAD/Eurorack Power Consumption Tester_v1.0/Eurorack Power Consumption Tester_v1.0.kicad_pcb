# Repository StudioKAT/EurorackPowerConsumptionTester

File README.md:

# Eurorack Power Consumption Tester

## 概要 / Overview

**Eurorack Power Consumption Tester** は、モジュラーシンセサイザーの消費電力を測定するための治具です。  
デジタルマルチメーター（テスター）と組み合わせて使用し、+5V、+12V、-12Vの各電源レールにおける消費電流の測定が可能です。

**Eurorack Power Consumption Tester** is a utility jig for measuring the power consumption of modular synthesizers.  
Used in combination with a digital multimeter, it allows measurement of current draw on +5V, +12V, and -12V rails.

## 仕様 / Spec
- Format: External testing tool (not a rack-mounted module)  
- Function: Power Consumption Tester Jig
- Current needs: +12V: 0mA, -12V: 0mA (Passive)
- Width: 0 HP
- Depth: 10mm

## 販売 / Sales

現在販売予定はありません。

## ライセンス / License

この作品は [Creative Commons 表示 - 継承 4.0 国際 (CC BY-SA 4.0)](https://creativecommons.org/licenses/by-sa/4.0/deed.ja) の下でライセンスされています。  
This work is licensed under the [Creative Commons Attribution-ShareAlike 4.0 International License](https://creativecommons.org/licenses/by-sa/4.0/).

## クレジット / Credits

- Designed by : StudioKAT
- Website : https://www.studiokat.jp/
- GitHub : https://github.com/StudioKAT
- X(Twitter) : https://x.com/StudioKAT_synth
- Instagram : https://www.instagram.com/studiokat_modular/

## 更新履歴 / Changelog

- `2025-04-24` v1.0 Released version 1.0

## KiCad design v1.0/KiCAD/Eurorack Power Consumption Tester_v1.0/Eurorack Power Consumption Tester_v1.0.kicad_pcb

Parts:
D1, D2, D3: LED; LED_D3.0mm
F1, F2, F3: MF-R050; Fuse_Bourns_MF-RG300
H1, H2, H3, H4, H5, H6: Banana; MountingHole_4.3mm_M4_DIN965_Pad
H7: Logo; StudioKAT_logo
H8, H9, H10, H11: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: IN; BoxHeader_2x08_2.54mm_Europower
J2: OUT; BoxHeader_2x08_2.54mm_Europower
R1: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 2.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3: SW_SPDT; SPDT

Connections:
+5V: F1.1, J1.5, J1.6
+5V_OUT: D1.2 (A), H4.1, J2.5, J2.6, SW1.1 (A)
+12V: F2.1, J1.7, J1.8
+12V_OUT: D2.2 (A), H5.1, J2.7, J2.8, SW2.1 (A)
-12V: F3.1, J1.15, J1.16
-12V_OUT: D3.1 (K), H6.1, J2.15, J2.16, SW3.1 (A)
GND: H8.1, H9.1, H10.1, H11.1, J1.9, J1.10, J1.11, J1.12, J1.13, J1.14, J2.9, J2.10, J2.11, J2.12, J2.13, J2.14, R1.2, R2.2, R3.2
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D3.2 (A), R3.1
unnamed: J1.1, J1.2, J2.1, J2.2
unnamed: J1.3, J1.4, J2.3, J2.4
unnamed: F1.2, H1.1, SW1.2 (B)
unnamed: F2.2, H2.1, SW2.2 (B)
unnamed: F3.2, H3.1, SW3.2 (B)

Notes on the sheet:
[部品リスト] ターミナル(バインディングポスト) 赤 MB-124-N-RED x3 ターミナル(バインディングポスト) 黒 MB-124-N-BLACK x3 リセッタブルヒューズ 0.5A トリップ電流:1A 耐圧:60V MF-R050 x3 3Pトグルスイッチ 1回路2接点 パネル取付用 1MS1-T1-B1-M1-Q-N x3 赤色3mmLED x3 0603 1kΩ x1 0603 2.2kΩ x2 IDCコネクタ16P x2

Board: 2 copper layers, 91.0 x 44.0 mm, 25 parts (0 on the bottom side), 15 nets.

## Commit log

2025-05-23 KiCADプロジェクト追加
2025-06-08 ディレクトリ構成変更
2025-06-08 画像リンク切れ修正
